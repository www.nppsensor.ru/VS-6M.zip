# KOMPAS-3D part (éæ-6î.m3d)

Model tree:
1. Объединить компоненты:1

Referenced files in D:\Работа\Мещеряков\Сигнализатор ВС\Черновики\: ВС-6М (.065, .067).a3d